# IAR project test02.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..; ..\STM32F4-Discovery_FW\Libraries\CMSIS\Include; ..\STM32F4-Discovery_FW\Libraries\CMSIS\ST\STM32F4xx\Include; ..\STM32F4-Discovery_FW\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\STM32F4-Discovery_FW\\Utilities\STM32F4-Discovery; ..\STM32F4-Discovery_FW\\Utilities\STM32_EVAL\STM3240_41_G_EVAL; ..\STM32F4-Discovery_FW\\Utilities\STM32_EVAL\Common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: test02.bin
  ILINK.IlinkOutputFile: test02.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group EWARM
    ./: startup_stm32f4xx.s
  group STM32F4-Discovery
    ../STM32F4-Discovery_FW/Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4-Discovery_FW/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_usart.c
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
